Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_34_BYy4r/format_2/3260(architecture=300).ifc
Time: 2025-09-01T09:05:26
Made in: PARTsolutions

# IfcProject, 3260(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3260(architecture=300)
In: BUILDING
Description: 3260(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3260
ePset_PARTsolutions - NB: 3260(architecture=300); NN: 3260; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3260(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3260; B: 3260_aluvia_900x1200.png; C: ALUVIA; E: KALDEWEI; EF000049: 900; EF004567: 1200; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 1200; etim7_EC003246_LENGTH: 900
